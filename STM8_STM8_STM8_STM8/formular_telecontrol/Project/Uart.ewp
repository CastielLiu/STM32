# IAR project Uart.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\USER; $TOOLKIT_DIR$\inc\; C:\Users\castiel_liu\Desktop\STM8\STM8其他资料\风驰开源STM8寄存器版本例程\4-Uart\Uart
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Uart.hex
  ILINK.IlinkOutputFile: Uart.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group USER
    ../USER/: clk_conf.c delay_.c led.c main.c pstwo.c stm8s_interruput.c uart.c
